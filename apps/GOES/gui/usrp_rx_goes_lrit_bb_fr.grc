<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>usrp_rx_goes_lrit_bb_fr</value></param>
<param><key>title</key><value>USRP LRIT Receiver</value></param>
<param><key>author</key><value>Martin Blaho</value></param>
<param><key>description</key><value>GOES - LRIT receive to baseband and decode signal to CADU</value></param>
<param><key>generate_options</key><value>wx_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0</value></param>
<param><key>stream_id</key><value>filtered_baseband</value></param>
</block>
<block>
<key>gr_complex_to_real</key>
<param><key>id</key><value>gr_complex_to_real_0</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>gr_packed_to_unpacked_xx</key>
<param><key>id</key><value>gr_packed_to_unpacked_xx_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>bits_per_chunk</key><value>1</value></param>
<param><key>endianness</key><value>gr.GR_MSB_FIRST</value></param>
<param><key>num_ports</key><value>1</value></param>
</block>
<block>
<key>gr_multiply_const_vxx</key>
<param><key>id</key><value>gr_multiply_const_vxx_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>const</key><value>1</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0_0</value></param>
<param><key>stream_id</key><value>synced_symbols</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0</value></param>
<param><key>stream_id</key><value>filtered_baseband</value></param>
</block>
<block>
<key>gr_agc_xx</key>
<param><key>id</key><value>gr_agc_xx_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>rate</key><value>10e-6</value></param>
<param><key>reference</key><value>1</value></param>
<param><key>gain</key><value>1.0/32767.0</value></param>
<param><key>max_gain</key><value>1.0</value></param>
</block>
<block>
<key>root_raised_cosine_filter</key>
<param><key>id</key><value>root_raised_cosine_filter_0</value></param>
<param><key>type</key><value>fir_filter_ccf</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>sym_rate</key><value>symb_rate</value></param>
<param><key>alpha</key><value>0.25</value></param>
<param><key>ntaps</key><value>int(11*samp_rate/symb_rate)</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>pll_alpha_sl</value></param>
<param><key>label</key><value>PLL Alpha</value></param>
<param><key>value</key><value>pll_alpha</value></param>
<param><key>min</key><value>0.001</value></param>
<param><key>max</key><value>0.1</value></param>
<param><key>num_steps</key><value>100</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>grid_pos</key><value>1,0,1,1</value></param>
<param><key>notebook</key><value>rx_ntb, 1</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>clock_alpha_sl</value></param>
<param><key>label</key><value>Clock alpha</value></param>
<param><key>value</key><value>clock_alpha</value></param>
<param><key>min</key><value>0.001</value></param>
<param><key>max</key><value>0.1</value></param>
<param><key>num_steps</key><value>100</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>grid_pos</key><value>1,1,1,1</value></param>
<param><key>notebook</key><value>rx_ntb, 1</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note4</value></param>
<param><key>note</key><value>Synchronchronizer</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note5</value></param>
<param><key>note</key><value>Viterbi decoder</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note7</value></param>
<param><key>note</key><value>Demodulator</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note0</value></param>
<param><key>note</key><value>RX generally info text's</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note1</value></param>
<param><key>note</key><value>Viterbi info text's</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note1_0</value></param>
<param><key>note</key><value>Deframer info text's</value></param>
</block>
<block>
<key>variable_static_text</key>
<param><key>id</key><value>deframer_check_sync_text</value></param>
<param><key>label</key><value>Deframer check sync enable</value></param>
<param><key>value</key><value>deframer_sync_check</value></param>
<param><key>converver</key><value>str_converter</value></param>
<param><key>formatter</key><value>None</value></param>
<param><key>grid_pos</key><value>2,0,1,1</value></param>
<param><key>notebook</key><value>rx_ntb,3</value></param>
</block>
<block>
<key>variable_static_text</key>
<param><key>id</key><value>deframer_sync_after_text</value></param>
<param><key>label</key><value>Deframe sync after</value></param>
<param><key>value</key><value>deframer_insync_frames</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>formatter</key><value>None</value></param>
<param><key>grid_pos</key><value>3,0,1,1</value></param>
<param><key>notebook</key><value>rx_ntb,3</value></param>
</block>
<block>
<key>variable_static_text</key>
<param><key>id</key><value>deframer_nosync_after_text</value></param>
<param><key>label</key><value>Deframer out of sync after</value></param>
<param><key>value</key><value>deframer_outsync_frames</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>formatter</key><value>None</value></param>
<param><key>grid_pos</key><value>4,0,1,1</value></param>
<param><key>notebook</key><value>rx_ntb,3</value></param>
</block>
<block>
<key>variable_static_text</key>
<param><key>id</key><value>viterbi_node_sync_text</value></param>
<param><key>label</key><value>Viterbi node sync enable</value></param>
<param><key>value</key><value>viterbi_sync_check</value></param>
<param><key>converver</key><value>str_converter</value></param>
<param><key>formatter</key><value>None</value></param>
<param><key>grid_pos</key><value>2,0,1,1</value></param>
<param><key>notebook</key><value>rx_ntb,2</value></param>
</block>
<block>
<key>variable_static_text</key>
<param><key>id</key><value>viterbi_sync_after_text</value></param>
<param><key>label</key><value>Valid frames for Viterbi decoder sync</value></param>
<param><key>value</key><value>viterbi_insync_frames</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>formatter</key><value>None</value></param>
<param><key>grid_pos</key><value>4,0,1,1</value></param>
<param><key>notebook</key><value>rx_ntb,2</value></param>
</block>
<block>
<key>variable_static_text</key>
<param><key>id</key><value>viterbi_outofsync_after_text</value></param>
<param><key>label</key><value>Invalid frames for Viterbi decoder out of sync</value></param>
<param><key>value</key><value>viterbi_outsync_frames</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>formatter</key><value>None</value></param>
<param><key>grid_pos</key><value>5,0,1,1</value></param>
<param><key>notebook</key><value>rx_ntb,2</value></param>
</block>
<block>
<key>gr_null_sink</key>
<param><key>id</key><value>gr_null_sink_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>gr_file_sink</key>
<param><key>id</key><value>gr_file_sink_0_1</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>file</key><value>frames_file</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>fec_decode_viterbi_bpsk_fb</key>
<param><key>id</key><value>fec_decode_viterbi_bpsk_fb_0</value></param>
<param><key>sync_check</key><value>viterbi_sync_check</value></param>
<param><key>ber_threshold</key><value>viterbi_sync_threshold</value></param>
<param><key>insync_after</key><value>viterbi_insync_frames</value></param>
<param><key>outsync_after</key><value>viterbi_outsync_frames</value></param>
<param><key>reset_after</key><value>viterbi_outsync_frames*3</value></param>
</block>
<block>
<key>poesweather_metop_cadu_deframer</key>
<param><key>id</key><value>poesweather_metop_cadu_deframer_0</value></param>
<param><key>sync_check</key><value>True</value></param>
<param><key>frame_length</key><value>1024</value></param>
<param><key>insync_after</key><value>deframer_insync_frames</value></param>
<param><key>outsync_after</key><value>deframer_outsync_frames</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_1</value></param>
<param><key>stream_id</key><value>synced_symbols</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note3</value></param>
<param><key>note</key><value>USRP receiver</value></param>
</block>
<block>
<key>variable_text_box</key>
<param><key>id</key><value>gain_tb</value></param>
<param><key>label</key><value>RX gain [dB]</value></param>
<param><key>value</key><value>gain</value></param>
<param><key>converver</key><value>int_converter</value></param>
<param><key>formatter</key><value>None</value></param>
<param><key>grid_pos</key><value>1,2,1,1</value></param>
<param><key>notebook</key><value>rx_ntb,0</value></param>
</block>
<block>
<key>variable_text_box</key>
<param><key>id</key><value>freq_tb</value></param>
<param><key>label</key><value>Frequency</value></param>
<param><key>value</key><value>freq</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>formatter</key><value>None</value></param>
<param><key>grid_pos</key><value>1,1,1,1</value></param>
<param><key>notebook</key><value>rx_ntb,0</value></param>
</block>
<block>
<key>variable_static_text</key>
<param><key>id</key><value>samp_rate_st</value></param>
<param><key>label</key><value>Sample rate</value></param>
<param><key>value</key><value>samp_rate</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>formatter</key><value>None</value></param>
<param><key>grid_pos</key><value>1,4,1,1</value></param>
<param><key>notebook</key><value>rx_ntb, 0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>64e6/decim_tb</value></param>
</block>
<block>
<key>variable_text_box</key>
<param><key>id</key><value>decim_tb</value></param>
<param><key>label</key><value>Decimation</value></param>
<param><key>value</key><value>decim</value></param>
<param><key>converver</key><value>int_converter</value></param>
<param><key>formatter</key><value>None</value></param>
<param><key>grid_pos</key><value>1,3,1,1</value></param>
<param><key>notebook</key><value>rx_ntb,0</value></param>
</block>
<block>
<key>variable_static_text</key>
<param><key>id</key><value>satellite_text</value></param>
<param><key>label</key><value>Sat </value></param>
<param><key>value</key><value>satellite</value></param>
<param><key>converver</key><value>str_converter</value></param>
<param><key>formatter</key><value>None</value></param>
<param><key>grid_pos</key><value>1,0,1,1</value></param>
<param><key>notebook</key><value>rx_ntb,0</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>notexxx</value></param>
<param><key>note</key><value>No more Used!!! was renamed to "deframer_sync_check"</value></param>
</block>
<block>
<key>notebook</key>
<param><key>id</key><value>rx_ntb</value></param>
<param><key>style</key><value>wx.NB_TOP</value></param>
<param><key>labels</key><value>['USRP Receiver', 'PLL demodulator and Clock sync', 'Viterbi decoder', 'Deframer','Output']</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0_1</value></param>
<param><key>import</key><value>from time import strftime, localtime, gmtime</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import math, os</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note8</value></param>
<param><key>note</key><value>Output data</value></param>
</block>
<block>
<key>variable_static_text</key>
<param><key>id</key><value>datetime_text</value></param>
<param><key>label</key><value>Local time of aquisition start</value></param>
<param><key>value</key><value>strftime("%A, %B %d %Y %H:%M:%S", localtime())</value></param>
<param><key>converver</key><value>str_converter</value></param>
<param><key>formatter</key><value>None</value></param>
<param><key>grid_pos</key><value>1,0,1,1</value></param>
<param><key>notebook</key><value>rx_ntb,4</value></param>
</block>
<block>
<key>variable_static_text</key>
<param><key>id</key><value>frames_file_text_inf</value></param>
<param><key>label</key><value>Frames filename</value></param>
<param><key>value</key><value>frames_file</value></param>
<param><key>converver</key><value>str_converter</value></param>
<param><key>formatter</key><value>None</value></param>
<param><key>grid_pos</key><value>3,0,1,1</value></param>
<param><key>notebook</key><value>rx_ntb,4</value></param>
</block>
<block>
<key>variable_static_text</key>
<param><key>id</key><value>baseband_file_text_inf</value></param>
<param><key>label</key><value>Baseband filename</value></param>
<param><key>value</key><value>baseband_file</value></param>
<param><key>converver</key><value>str_converter</value></param>
<param><key>formatter</key><value>None</value></param>
<param><key>grid_pos</key><value>4,0,1,1</value></param>
<param><key>notebook</key><value>rx_ntb,4</value></param>
</block>
<block>
<key>gr_clock_recovery_mm_xx</key>
<param><key>id</key><value>gr_clock_recovery_mm_xx_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>omega</key><value>sps</value></param>
<param><key>gain_omega</key><value>clock_alpha_sl*clock_alpha_sl/4.0</value></param>
<param><key>mu</key><value>0.5</value></param>
<param><key>gain_mu</key><value>clock_alpha_sl</value></param>
<param><key>omega_relative_limit</key><value>0.05</value></param>
</block>
<block>
<key>gr_costas_loop_cc</key>
<param><key>id</key><value>gr_costas_loop_cc_0</value></param>
<param><key>alpha</key><value>pll_alpha_sl</value></param>
<param><key>beta</key><value>pll_alpha_sl*pll_alpha_sl/4.0</value></param>
<param><key>max_freq</key><value>0.07</value></param>
<param><key>min_freq</key><value>-0.07</value></param>
<param><key>order</key><value>2</value></param>
</block>
<block>
<key>gr_sig_source_x</key>
<param><key>id</key><value>gr_sig_source_x_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>waveform</key><value>gr.GR_COS_WAVE</value></param>
<param><key>freq</key><value>100000</value></param>
<param><key>amp</key><value>1</value></param>
<param><key>offset</key><value>0</value></param>
</block>
<block>
<key>gr_throttle</key>
<param><key>id</key><value>gr_throttle_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>usrp_simple_source_x</key>
<param><key>id</key><value>usrp_simple_source</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>format</key><value></value></param>
<param><key>which</key><value>0</value></param>
<param><key>decimation</key><value>decim_tb</value></param>
<param><key>frequency</key><value>freq_tb</value></param>
<param><key>lo_offset</key><value>float('inf')</value></param>
<param><key>gain</key><value>gain_tb</value></param>
<param><key>side</key><value>side</value></param>
<param><key>rx_ant</key><value>RXA</value></param>
<param><key>hb_filters</key><value></value></param>
</block>
<block>
<key>gr_file_sink</key>
<param><key>id</key><value>gr_file_sink_0</value></param>
<param><key>file</key><value>baseband_file</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>wxgui_fftsink2</key>
<param><key>id</key><value>wxgui_fftsink1</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>title</key><value>Not filtered spectrum</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>baseband_freq</key><value>freq</value></param>
<param><key>y_per_div</key><value>2</value></param>
<param><key>y_divs</key><value>10</value></param>
<param><key>ref_level</key><value>12</value></param>
<param><key>ref_scale</key><value>2.0</value></param>
<param><key>fft_size</key><value>1024</value></param>
<param><key>fft_rate</key><value>30</value></param>
<param><key>peak_hold</key><value>False</value></param>
<param><key>average</key><value>True</value></param>
<param><key>avg_alpha</key><value>0.1</value></param>
<param><key>win</key><value>None</value></param>
<param><key>notebook</key><value>rx_ntb, 0</value></param>
</block>
<block>
<key>wxgui_scopesink2</key>
<param><key>id</key><value>wxgui_scopesink2_1</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>title</key><value>BPSK constellation diagram</value></param>
<param><key>samp_rate</key><value>symb_rate</value></param>
<param><key>v_scale</key><value>0.4</value></param>
<param><key>v_offset</key><value>0</value></param>
<param><key>t_scale</key><value>1/samp_rate</value></param>
<param><key>ac_couple</key><value>False</value></param>
<param><key>xy_mode</key><value>True</value></param>
<param><key>num_inputs</key><value>1</value></param>
<param><key>notebook</key><value>rx_ntb,1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sps</value></param>
<param><key>value</key><value>samp_rate/symb_rate_tb</value></param>
</block>
<block>
<key>variable_text_box</key>
<param><key>id</key><value>symb_rate_tb</value></param>
<param><key>label</key><value>Symbol rate</value></param>
<param><key>value</key><value>symb_rate</value></param>
<param><key>converver</key><value>int_converter</value></param>
<param><key>formatter</key><value>None</value></param>
<param><key>grid_pos</key><value>2,1,1,1</value></param>
<param><key>notebook</key><value>rx_ntb,1</value></param>
</block>
<block>
<key>wxgui_fftsink2</key>
<param><key>id</key><value>wxgui_fftsink2</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>title</key><value>RRC filtered spectrum</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>baseband_freq</key><value>0</value></param>
<param><key>y_per_div</key><value>2</value></param>
<param><key>y_divs</key><value>10</value></param>
<param><key>ref_level</key><value>12</value></param>
<param><key>ref_scale</key><value>2.0</value></param>
<param><key>fft_size</key><value>1024</value></param>
<param><key>fft_rate</key><value>30</value></param>
<param><key>peak_hold</key><value>False</value></param>
<param><key>average</key><value>True</value></param>
<param><key>avg_alpha</key><value>0.1</value></param>
<param><key>win</key><value>None</value></param>
<param><key>notebook</key><value>rx_ntb,0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>viterbi_sync_check</value></param>
<param><key>label</key><value>Viterbi node synchronisation check active</value></param>
<param><key>value</key><value>True</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>viterbi_insync_frames</value></param>
<param><key>label</key><value>Count of valid data BER test's after which Viterbi go in to synced state</value></param>
<param><key>value</key><value>5</value></param>
<param><key>type</key><value>intx</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>deframer_insync_frames</value></param>
<param><key>label</key><value>Count of valid ASM's after which deframer go in to synced state</value></param>
<param><key>value</key><value>2</value></param>
<param><key>type</key><value>intx</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>deframer_outsync_frames</value></param>
<param><key>label</key><value>Count of invalid ASM's after which deframer go out of synced state</value></param>
<param><key>value</key><value>5</value></param>
<param><key>type</key><value>intx</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>viterbi_outsync_frames</value></param>
<param><key>label</key><value>Count of  non valid data BER test's after which Viterbi go out of synced state</value></param>
<param><key>value</key><value>20</value></param>
<param><key>type</key><value>intx</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note6</value></param>
<param><key>note</key><value>Deframer</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>deframer_sync_check</value></param>
<param><key>label</key><value>Deframer synchronisation check active</value></param>
<param><key>value</key><value>True</value></param>
</block>
<block>
<key>variable_static_text</key>
<param><key>id</key><value>viterbi_sync_threshold_text</value></param>
<param><key>label</key><value>Viterbi node sync threshold [BER]</value></param>
<param><key>value</key><value>viterbi_sync_threshold</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>formatter</key><value>None</value></param>
<param><key>grid_pos</key><value>3,0,1,1</value></param>
<param><key>notebook</key><value>rx_ntb,2</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>pll_alpha</value></param>
<param><key>label</key><value>PLL alpha</value></param>
<param><key>value</key><value>0.005</value></param>
<param><key>type</key><value>eng_float</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>symb_rate</value></param>
<param><key>label</key><value>Symbol rate</value></param>
<param><key>value</key><value>293883</value></param>
<param><key>type</key><value>intx</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>clock_alpha</value></param>
<param><key>label</key><value>Clock alpha</value></param>
<param><key>value</key><value>0.005</value></param>
<param><key>type</key><value>eng_float</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>viterbi_sync_threshold</value></param>
<param><key>label</key><value>Viterbi node sync threshold [BER]</value></param>
<param><key>value</key><value>0.1</value></param>
<param><key>type</key><value>eng_float</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>frames_file</value></param>
<param><key>label</key><value>CADU frames output filename</value></param>
<param><key>value</key><value>os.environ['HOME'] + '/GOES-LRIT_cadu_frames.cadu'</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>satellite</value></param>
<param><key>label</key><value>Satellite</value></param>
<param><key>value</key><value>'GOES-LRIT'</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>freq</value></param>
<param><key>label</key><value>Frequency</value></param>
<param><key>value</key><value>1691.02e6</value></param>
<param><key>type</key><value>eng_float</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>gain</value></param>
<param><key>label</key><value>Gain</value></param>
<param><key>value</key><value>23</value></param>
<param><key>type</key><value>eng_float</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>decim</value></param>
<param><key>label</key><value>Decimation</value></param>
<param><key>value</key><value>108</value></param>
<param><key>type</key><value>intx</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>side</value></param>
<param><key>label</key><value>Side</value></param>
<param><key>value</key><value>A</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>sync_check</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>label</key><value>Sync check</value></param>
<param><key>value</key><value>True</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>short_id</key><value>c</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>baseband_file</value></param>
<param><key>label</key><value>Baseband output filename</value></param>
<param><key>value</key><value>os.environ['HOME'] + '/GOES-LRIT_baseband.dat'</value></param>
<param><key>type</key><value>string</value></param>
</block>
<connection><source_block_id>root_raised_cosine_filter_0</source_block_id><sink_block_id>virtual_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_agc_xx_0</source_block_id><sink_block_id>root_raised_cosine_filter_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_1</source_block_id><sink_block_id>gr_complex_to_real_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fec_decode_viterbi_bpsk_fb_0</source_block_id><sink_block_id>gr_packed_to_unpacked_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_packed_to_unpacked_xx_0</source_block_id><sink_block_id>poesweather_metop_cadu_deframer_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_complex_to_real_0</source_block_id><sink_block_id>fec_decode_viterbi_bpsk_fb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>poesweather_metop_cadu_deframer_0</source_block_id><sink_block_id>gr_file_sink_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_clock_recovery_mm_xx_0</source_block_id><sink_block_id>gr_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_costas_loop_cc_0</source_block_id><sink_block_id>gr_clock_recovery_mm_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_multiply_const_vxx_0</source_block_id><sink_block_id>virtual_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0</source_block_id><sink_block_id>gr_costas_loop_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_multiply_const_vxx_0</source_block_id><sink_block_id>wxgui_scopesink2_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>root_raised_cosine_filter_0</source_block_id><sink_block_id>wxgui_fftsink2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_agc_xx_0</source_block_id><sink_block_id>wxgui_fftsink1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>poesweather_metop_cadu_deframer_0</source_block_id><sink_block_id>gr_null_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_sig_source_x_0</source_block_id><sink_block_id>gr_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_throttle_0</source_block_id><sink_block_id>gr_agc_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>usrp_simple_source</source_block_id><sink_block_id>gr_agc_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>usrp_simple_source</source_block_id><sink_block_id>gr_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
